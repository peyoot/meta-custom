# 禁用 gstreamer 以避免 vulkan 编译错误
RDEPENDS:${PN} = ""