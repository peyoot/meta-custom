RDEPENDS:${PN}:remove = "bluez5-init"