DISTRO_FEATURES:append = " rt"

IMAGE_ROOTFS_MAXSIZE = "6291456"